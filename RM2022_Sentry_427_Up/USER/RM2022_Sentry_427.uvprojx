# Keil uVision project RM2022_Sentry_427.uvprojx, settings and files
target Sentry (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2022_Sentry_427
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED =1
  c include: ..\USER;..\CORE;..\TASK;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\BEEP;..\HARDWARE\LASER;..\HARDWARE\CAN;..\HARDWARE\DR16;..\HARDWARE\TIM6;..\HARDWARE\PID;..\HARDWARE\CHASSIS;..\HARDWARE\CAN_HANDLE;..\HARDWARE\SPI;..\HARDWARE\IMU;..\HARDWARE\GIMBAL;..\HARDWARE\POWER;..\HARDWARE\NUC;..\HARDWARE\REFEREE;..\HARDWARE\SHOOT;..\HARDWARE\COVER;..\HARDWARE\BEEP;..\HARDWARE\LED;..\HARDWARE\DUALBOARD
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/CAN_HANDLE/: can_handle.c
    ../HARDWARE/COVER/: cover.c
    ../HARDWARE/DR16/: dr16.c
    ../HARDWARE/GIMBAL/: gimbal.c
    ../HARDWARE/IMU/: imu.c
    ../HARDWARE/LASER/: laser.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/POWER/: power.c
    ../HARDWARE/REFEREE/: crc.c referee_info.c referee.c
    ../HARDWARE/SHOOT/: shoot.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIM6/: tim6.c
    ../HARDWARE/DUALBOARD/: dual_board.c
    ../HARDWARE/CHASSIS/: chassis.c
    ../HARDWARE/NUC/: nuc.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f427xx.s
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group TASK
    ../TASK/: can_send_task.c chassis_task.c gimbal_task.c imu_task.c led_task.c mode_task.c nuc_task.c shoot_task.c task_init.c task_init.h
